Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-14T13:38:18
Author: Scarlett Alday, s.aldayaranda@gmail.com
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Dec 14 13:38:18 2023 * Host: LAPTOP-VOCR0U39 * Database: C:\Users\salda\AppData\Local\Temp\cf07efaf-b963-45d9-bf45-b97a93fbf848\dc5b3ce0-cdb8-4ac8-9085-d6d7164c2985\ifc * Database version: 5507 * Database creation date: Thu Dec 14 13:38:18 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Dec 14 13:38:18 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Dec 14 13:38:18 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Deceuninck_Ventana_Oscilobatiente_Everest-Max:Deceuninck_Ventana_Oscilobatiente_Everest-Max, Deceuninck_Ventana_Oscilobatiente_Everest-Max:Deceuninck_Ventana_Oscilobatiente_Everest-Max:524362
In: Level 1
Type - Classification: B2020100 Windows (Uniformat); Material: Deceuninck - 1.Blanco/PVC, PVC, Galvanized steel, Glass
Type - Analytical Properties - Analytic Construction: <None>; Define Thermal Properties by: Schematic Type
Type - Construction - Wall Closure: By host
Type - Dimensions - Construction Height: 1305 mm; Construction Width: 1005 mm; Glass Height: 804 mm; Glass Width: 1104 mm; Height: 1300 mm; Max. Height: 1500 mm; Max. Width: 1000 mm; Rough Height: 1232 mm; Sash Fit: 34 mm; Width: 1000 mm
Type - Identity Data - Assembly Code: B2020100; Assembly Description: Windows; Constructive depth: 60mm; C-Section Model: https://skfb.ly/oOwKS; Glass Type: Monolitic, laminated, thermopanel; Glazing capacity: 4 - 36mm; Internacional Certification: ISO 9001-ISO 14001-BS OHSAS 18001 approved by TUV Rheiland; Line: Everest Max; Maintenance: https://deceuninck.cl/pdf/mantencion.pdf; Manufacturer: Deceuninck; Model: Tilt and turn window; OmniClass Number: 23.30.20.00; OmniClass Title: Windows; Opening: Exterior; Panels: 1; Technical Area: info@deceuninckbim.cl; Type Comments: Calculations made based on load of 500 Pa (103km/h); Type Mark: 91; Type Name: Deceuninck_Ventana_Oscilobatiente_Everest-Max; URL: www.deceuninck.cl; Use: Interior
Type - Materials and Finishes - Available colours: https://deceuninckbim.cl/pdf/fichas/Everest-max-Oscilobatiente.pdf; Frame: Deceuninck - 1.Blanco/PVC; Handle: PVC; Reinforcement: Galvanized steel; Sash: Deceuninck - 1.Blanco/PVC
Type - Model Properties - Acoustic insulation: Rw=33 (-1;-4) dB according to ISO 140-3, ISO 717 **; Air permeability: Class 4 according to EN 12207; Fire Rating: Class C-s3, d2 according to EN 13501-1; Water tightness: Class 9A according to EN 12208; Wind load resistance: Class C1/B2 according to EN 12210
Type - Other - Category: Windows; Altura de antepecho por defecto: 900 mm; Family Name: Deceuninck_Ventana_Oscilobatiente_Everest-Max
Type - Structural - Includes reinforcement: yes
Material: Glass, Deceuninck - 1.Blanco/PVC
Constraints - Level: Level: Level 1; Sill Height: 900 mm
Dimensions - Area: 3.12931 m2; Volume: 0.0298983 m3
Identity Data - Mark: 80
Other - Family: Deceuninck_Ventana_Oscilobatiente_Everest-Max: Deceuninck_Ventana_Oscilobatiente_Everest-Max; Family and Type: Deceuninck_Ventana_Oscilobatiente_Everest-Max: Deceuninck_Ventana_Oscilobatiente_Everest-Max; Head Height: 2200 mm; Host Id: Basic Wall: Generic - 200mm; ON_OFF - Height: no; ON_OFF - Width: no; Type: Deceuninck_Ventana_Oscilobatiente_Everest-Max: Deceuninck_Ventana_Oscilobatiente_Everest-Max; Type Id: Deceuninck_Ventana_Oscilobatiente_Everest-Max: Deceuninck_Ventana_Oscilobatiente_Everest-Max
Phasing - Phase Created: New Construction
